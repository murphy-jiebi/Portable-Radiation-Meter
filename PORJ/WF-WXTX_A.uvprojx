# Keil uVision project WF-WXTX_A.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WF-WXTA_A +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F10X_HD
  c include: ..\CMSIS;..\GDLIB\Include;..\INC;..\BSP;..\USER;..\ModBus;..\APP;..\GUI
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/: system_gd32f10x.c startup_gd32f10x_hd.s
  group GDLIB
    ../GDLIB/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group BSP
    ../BSP/: bsp_eeprom.c bsp_gpio.c bsp_uart.c bsp_timer.c bsp_adc.c bsp_rtc.c bsp_pwm.c bsp_key.c bsp_lcd.c
  group USER
    ../USER/: gd32f10x_it.c main.c sys.c sys_config.c
  group INC
    ../INC/: bsp.h gd32f10x_it.h gd32f10x_libopt.h user.h
  group APP
    ../APP/: Task_com.c Task_gui.c Task_dose.c Task_status.c Task_manage.c
  group Modbus
    ../ModBus/: modbus_slave.c
  group GUI
    ../GUI/: gui.c display.c
